## src/packages/mkbootimg/Config.in.host
```kconfig
config BR2_PACKAGE_HOST_MKBOOTIMG
  bool "host mkbootimg"
  help
    It is mkbootimg.
```
